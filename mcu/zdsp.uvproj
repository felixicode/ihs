# Keil uVision project zdsp.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: zdsp +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c uart.c wk2xxx.c delay.c print.c ec.c dtu.c i2c.c i2c.h rtc.c rtc.h ph_i2c.c ph.c ph.h ec.h dtu.h delay.h
